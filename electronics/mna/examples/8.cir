Iin 1 0 Symbolic
R1 1 0 Symbolic
R2 1 2 Symbolic
C1 1 2 Symbolic
Oa 0 1 2
