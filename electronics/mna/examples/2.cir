Is1 1 0 5
Vs1 1 2 5
R1 1 0 1
R2 1 2 2
R3 2 0 3
