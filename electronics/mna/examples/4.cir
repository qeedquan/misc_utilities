Vb 1 0 30
Is 2 0 2
R1 1 2 5
R2 2 0 3
R3 2 0 10
