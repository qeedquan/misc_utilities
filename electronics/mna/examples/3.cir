Vbatt 1 0 40
Isrc 4 0 1
R1 1 2 2
R2 2 3 9
R3 3 4 8
R4 2 0 10
R6 3 0 4
