Vg 1 0 1
Vx 3 2 1
It 2 1 1
R1 1 2 1
R2 2 0 1
R3 3 0 1
