V1 2 1 32
V2 3 0 20
R1 0 1 2
R2 2 3 4
R3 2 0 8
