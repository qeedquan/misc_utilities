options:
  parameters:
    generate_options: qt_gui
    id: am_recording_usrp
    output_language: python
    title: AM Recording USRP
  states: {}

blocks:
- name: resamp_factor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 256e3
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: am_usrp710.dat
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: '0.003'
    type: float
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 5e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate/resamp_factor
    type: fir_filter_ccf
    width: 1e2
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The AM signal was recorded at center frequency 710 khz.
      The waveform in the file shifted to the baseband so the center frequency is now zero when displayed on the scope.

      The AM signal has 5khz of bandwidth.
      To isolate the AM sound signal, downsample to 64k (samp_rate/samp_factor) and apply a low pass filter with cutoff frequency of 5 khz.
      The 5 khz lowpass filter applies to both sides of the baseband.
      Can also skip the downsample to 64k and go directly from 256khz to 48 khz at the rational resampler at the floating point output.

      The output of the lowpass filter is the audio signal scaled.
      Convert the complex number into a magnitude and rescale it to [0, 1] range
      for floating point audio output. Need to also resample the 64khz to 48 khz by another rational resampler.
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate/resamp_factor
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    nconnections: '2'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '100'
    ymin: '-100'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
    ymin: '0'
  states: {}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: resamp_factor
    interp: '1'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    interp: '3'
    taps: ''
    type: fff
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_multiply_const_vxx_0, '0']
- [blocks_file_source_0, '0', rational_resampler_xxx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_0_0, '0']
- [low_pass_filter_0, '0', blocks_complex_to_mag_0, '0']
- [low_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [rational_resampler_xxx_0, '0', low_pass_filter_0, '0']
- [rational_resampler_xxx_0, '0', qtgui_freq_sink_x_0, '1']
- [rational_resampler_xxx_0_0, '0', audio_sink_0, '0']
- [rational_resampler_xxx_0_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
