options:
  parameters:
    generate_options: qt_gui
    id: chunks_to_symbols
    output_language: python
    title: Chunk to Symbols
  states: {}

blocks:
- name: psk_constellation
  id: variable_constellation
  parameters:
    precision: '8'
    type: qpsk
  states: {}
- name: value
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    rangeType: int
    start: '0'
    step: '1'
    stop: '255'
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: value
    type: byte
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: constellation.bin
    type: complex
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: '[1, 1j, -1, -1j]'
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      The other constellation modulators apply a filter (usually a raised cosine filter), so the mapping shown in the constellation diagram is not exact.
      Using chunks to symbols is exact if the symbols are within bounds of the table.
      If the symbol is outside of the table, an undefined value is returned.
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}

connections:
- [analog_const_source_x_0, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', blocks_file_sink_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', qtgui_const_sink_x_0, '0']

metadata:
  file_format: 1
