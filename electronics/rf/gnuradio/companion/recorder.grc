options:
  parameters:
    generate_options: qt_gui
    id: recorder
    output_language: python
    title: Recorder
  states: {}

blocks:
- name: frequency
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: 31e6
    step: 1e4
    stop: 33e6
    value: 32e6
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.56e6
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    append: 'True'
    file: raw_data.iq
    type: complex
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: 20e6
    fc: frequency
    fftsize: '1024'
    name: Spectrum
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    freq0: frequency
    gain0: '10'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [rtlsdr_source_0, '0', blocks_file_sink_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']

metadata:
  file_format: 1
