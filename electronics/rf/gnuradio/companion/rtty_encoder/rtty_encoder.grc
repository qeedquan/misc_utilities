options:
  parameters:
    generate_options: no_gui
    id: rtty_encoder
    output_language: python
    run_options: run
    title: 'RTTY Encoder '
  states: {}

blocks:
- name: baud
  id: variable
  parameters:
    value: 1/0.022
  states: {}
- name: center
  id: variable
  parameters:
    value: (mark+space)/2
  states: {}
- name: fsk_deviation
  id: variable
  parameters:
    value: '170'
  states: {}
- name: gain
  id: variable
  parameters:
    value: '2'
  states: {}
- name: inp_amp
  id: variable
  parameters:
    value: abs(mark-space)/vco_max
  states: {}
- name: mark
  id: variable
  parameters:
    value: '1585'
  states: {}
- name: repeat
  id: variable
  parameters:
    value: int(samp_rate/baud)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: space
  id: variable
  parameters:
    value: mark-fsk_deviation
  states: {}
- name: vco_max
  id: variable
  parameters:
    value: max(mark, space) + 100
  states: {}
- name: vco_offset
  id: variable
  parameters:
    value: min(space, mark)/vco_max
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: vco_offset
    type: float
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: input.bin
    repeat: 'False'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: inp_amp
    type: float
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: gain
    type: float
  states: {}
- name: blocks_repeat_0
  id: blocks_repeat
  parameters:
    interp: repeat
    type: float
  states: {state: disabled}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: '0.500'
    samp_rate: samp_rate
    sensitivity: (2*pi*vco_max)/1
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '16'
    file: output.wav
    samp_rate: samp_rate
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 4e3
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: 1e3
    win: firdes.WIN_HAMMING
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      https://en.wikipedia.org/wiki/Baudot_code

      RTTY Encoding is a form of BFSK.
      Each character frame has the following format:

      [number of start bits]
      [5 bit value that is an index to a character table lookup]
      [number of stop bits]

      The receiver is expected to have a character table that the index can be used.
      The most popular character encoding is ITA2.

      The easiest way to support fractional delay such as 1.5 stop bits, the input program can handle the repeats, though this lead to much larger input file sizes.
      If the repeat block is enabled here, the input can be smaller as it does not have repeats but it can only support whole integer repeats.

      A way to get fractional support in the flowgraph without the input being repeated for is to have a special value marker that scales the repeat.
    note: Outline
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: xmt_data
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: fsk_out
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: xmt_data
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: fsk_out
  states: {}

connections:
- [blocks_add_const_vxx_0, '0', blocks_vco_f_0, '0']
- [blocks_file_source_0, '0', blocks_repeat_0, '0']
- [blocks_file_source_0, '0', virtual_sink_0, '0']
- [blocks_multiply_const_vxx_0, '0', blocks_add_const_vxx_0, '0']
- [blocks_multiply_const_vxx_1, '0', virtual_sink_0_0, '0']
- [blocks_repeat_0, '0', virtual_sink_0, '0']
- [blocks_vco_f_0, '0', low_pass_filter_0, '0']
- [low_pass_filter_0, '0', blocks_multiply_const_vxx_1, '0']
- [virtual_source_0, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_1, '0', blocks_wavfile_sink_0, '0']

metadata:
  file_format: 1
