options:
  parameters:
    generate_options: qt_gui
    id: vco_drive
    output_language: python
    title: VCO Drive
  states: {}

blocks:
- name: amplitude
  id: variable
  parameters:
    value: '1'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 1e4
  states: {}
- name: voltage
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: samp_rate/2
    value: '0'
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: voltage
    type: float
  states: {}
- name: blocks_vco_f_0
  id: blocks_vco_f
  parameters:
    amplitude: amplitude
    samp_rate: samp_rate
    sensitivity: 2*pi
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from math import pi
  states: {}
- name: note_0
  id: note
  parameters:
    comment: |-
      Voltage Controlled Oscillator (VCO) is a device that takes voltage as an input and outputs a sinusoidal wave whose frequency is proportional to the magnitude of the input

      The sensitivity controls the max frequency the VCO can output, it is multiple of 2*pi and related to the sample rate.

      Some examples of the senstivity relationship with sample_rate and output frequency is shown below:

      Sensitivity | Input Source Range -> Output frequency of wave

      1*pi                       | [0, sample_rate/2] -> [0, sample_rate/4] frequency
      2*pi                       | [0, sample_rate/2] -> [0, sample_rate/2] frequency
      2*pi*value           | [0, 1]                         -> [0, value] frequency (Assumes value <= sample_rate/2)

      The amplitude parameter is a constant gain multiplied to the output.
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '10000'
    freqhalf: 'False'
    grid: 'True'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    size: '1024'
    srate: samp_rate
    type: float
  states: {}

connections:
- [analog_const_source_x_0, '0', blocks_vco_f_0, '0']
- [blocks_vco_f_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vco_f_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
